# Keil uVision project FreeRTOS.uvprojx, settings and files
target MI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MI +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\TimePwm;..\SYSTEM\usart1;..\SYSTEM\SystemTime;..\USMART;..\TEST_FUN\Test;..\TEST_FUN\DataScope;..\HARDWARE;..\Application\ROBOT\inc;..\HARDWARE\IOOutput;..\HARDWARE\ADC;..\HARDWARE\TimeCapture;..\HARDWARE\IIC;..\HARDWARE\EXTI;..\HARDWARE\SPI;..\HARDWARE\Gyroscope;..\HARDWARE\Garbage_boxes;..\Application\SHARE;..\HARDWARE\TIMER;..\USER;..\HARDWARE\USART;..\Protocol;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart1/: usart1.c
    ../SYSTEM/SystemTime/: SystemTime.c
  group HARDWARE
    ../HARDWARE/: HardwareManage.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/EXTI/: EXTI.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IOOutput/: iooutput.c
    ../HARDWARE/TimePwm/: TimePwm.c
    ../HARDWARE/TimeCapture/: TimeCapture.c
  group Application_Robot
    ../Application/ROBOT/src/: TaskManage.c BehaviorManage.c
  group Application_Share
    ../Application/SHARE/: mymath.c
  group Application_Motor
    ../Application/ROBOT/src/: ApplicationMotor.c
  group Application_Key
    ../Application/ROBOT/src/: ApplicationKey.c
  group Application_Led
    ../Application/ROBOT/src/: ApplicationLed.c
  group Application_ADC
    ../Application/ROBOT/src/: ApplicationADC.c
  group Application_Drop
    ../Application/ROBOT/src/: ApplicationDropCheck.c
  group Application_Bmi160
    ../HARDWARE/Gyroscope/: bmi160.c bmi160_data.c
  group Application_Protocol
    ../Protocol/: protocol.c FrameHandle.c
  group Application_Ultrasonic
    ../Application/ROBOT/src/: Application_Ultrasonic.c
  group Application_PowerChip
    ../Application/ROBOT/src/: ApplicationPowerChip.c
  group Application_GarBoxCheck
    ../HARDWARE/Garbage_boxes/: Garbage_boxes_check.c
  group FreeRTOS_CORE
    ../FreeRTOS/: list.c tasks.c timers.c queue.c croutine.c event_groups.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_fsmc.c stm32f10x_dbgmcu.c
  group usmart
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group testfunction
    ../TEST_FUN/Test/: testfun.c
    ../TEST_FUN/DataScope/: DataScope_DP.C
  group README
    ../: readme.txt
